# Keil uVision project Project.uvprojx, settings and files
target STM32F030 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xd000
  memory RVCT9: RAM 0x200000c0 size 0x1f00
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s startup_stm32f042.s startup_stm32f031.s startup_stm32f070xb.s startup_stm32f091.s startup_stm32f070x6.s startup_stm32f030xc.s startup_stm32f072.s startup_stm32f051.s
    ../: system_stm32f0xx.c
  group User
    ../: main.c stm32f0xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_pwr.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_adc.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_rtc.c stm32f0xx_gpio.c stm32f0xx_dbgmcu.c stm32f0xx_crc.c stm32f0xx_wwdg.c stm32f0xx_can.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_crs.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_cec.c
  group HARDWARE
    ../HARDWARE/: delay.c led.c magnet.c timer.c u485.c crc.c flash.c wdg.c dialswitch.c
